# IAR project SPI_1.ewp, settings and files
configuration Debug (MAXQ, debug)
  ICCMAXQ.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AMAXQ.AIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmaxq200x.xcl
configuration Release (MAXQ)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: 7_Bulk_Loop.c HID_KB_MAXQ.C SPI1.c SPIfuncs.c
