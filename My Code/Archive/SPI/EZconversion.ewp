# IAR project EZconversion.ewp, settings and files
configuration Debug (MAXQ, debug)
  ICCMAXQ.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AMAXQ.AIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmaxq200x.xcl
configuration Release (MAXQ)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../EZUSB_SPI/: 8_Bulk_Loop.c GPIOtest.c QHID_KB_R1.C QSPIfuncs.c
