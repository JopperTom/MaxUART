# IAR project SPI_stub.ewp, settings and files
configuration Debug (MAXQ, debug)
  ICCMAXQ.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmaxq200x.xcl
configuration Release (MAXQ)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: SPI functions.c
