# IAR project TC0050.ewp, settings and files
configuration Debug (MAXQ, debug)
  ICCMAXQ.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  AMAXQ.AIncludePaths: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmaxq200x.xcl
configuration Release (MAXQ)
  as the first configuration, except:
  group (top)
    ./: tc0050 .c
