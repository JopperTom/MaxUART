<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TCTEMPLATE_A\%TCTEMPLATE.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0000\TC0000.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0001\TC0001.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0002\TC0002.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0003\TC0003.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0004\TC0004.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0005\TC0005.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0006\TC0006.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0007\TC0007.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0008\TC0008.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0009\TC0009.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0010\TC0010.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0011\TC0011.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0012\TC0012.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0050\TC0050.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0100\TC0100.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0111\TC0111.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0120\TC0120.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0125\TC0125.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0127\TC0127.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0128\TC0128.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0129\TC0129.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0130\TC0130.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0131\TC0131.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0132\TC0132.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0133\TC0133.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0134\TC0134.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0135\TC0135.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0136\TC0136.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0137\TC0137.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0138\TC0138.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0139\TC0139.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0140\TC0140.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0141\TC0141.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0142\TC0142.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0143\TC0143.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0144\TC0144.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0145\TC0145.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0146\TC0146.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0147\TC0147.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0149\TC0149.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0150\TC0150.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0151\TC0151.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0152\TC0152.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0153\TC0153.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0154\TC0154.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0155\TC0155.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0156\TC0156.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0157\TC0157.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0159\TC0159.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0160\TC0160.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0161\TC0161.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0162\TC0162.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0163\TC0163.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0164\TC0164.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0165\TC0165.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0170\TC0170.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0200\TC0200.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0201\TC0201.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0211\TC0211.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0212\TC0212.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0213\TC0213.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0214\TC0214.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0296\TC0296.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0298\TC0298.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0299\TC0299.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0400\TC0400.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0500\TC0500.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0501\TC0501.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0600\TC0600.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0700\TC0700.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0701\TC0701.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0702\tc0702.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0703\TC0703.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0704\TC0704.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0750\TC0750.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0751\TC0751.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0800\TC0800.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0710\TC0710.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0900\TC0900.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0901\TC0901.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0910\TC0910.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0911\TC0911.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC0912\TC0912.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1000\TC1000.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1010\TC1010.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1020\TC1020.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1112\TC1112.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1113\TC1113.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1114\TC1114.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1115\TC1115.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1116\TC1116.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1117\TC1117.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TC1118\TC1118.ewp</path>
  </project>
  <project>
    <path>H:\Program Files\IAR Systems\Embedded Workbench 3.2\MAXQ\config\xxxSPI.ewp</path>
  </project>
  <batchBuild/>
</workspace>


