# IAR project TC0164.ewp, settings and files
configuration Debug (MAXQ, debug)
  ICCMAXQ.CCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkmaxq200x.xcl
configuration Release (MAXQ)
  as the first configuration, except:
  group (top)
    ./: tc0164.c
