<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TC0000.ewp</path>
  </project>
  <batchBuild/>
</workspace>


